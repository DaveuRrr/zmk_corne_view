## boards/shields/corne_left_peripheral/Kconfig.shield
```kconfig
config SHIELD_CORNE_LEFT_PERIPHERAL
    def_bool $(shields_list_contains,corne_left_peripheral)
```
